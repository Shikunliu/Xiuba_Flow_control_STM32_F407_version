# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: test +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\inc;..\board\inc;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\src\bsp\inc;..\src\bsp\src;..\src\bsp;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./: startup_stm32f4xx.s
  group user
    ../src/: main.c system_stm32f4xx.c stm32f4xx_it.c modbus_slave.c modbus_slave.h
  group board
    ../board/src/: usart.c
  group periph
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group bsp
    ../src/bsp/: bsp.c bsp.h
    ../src/bsp/src/: bsp_led.c bsp_timer.c bsp_limit_switch.c bsp_level_sensor_input.c bsp_uart_fifo.c bsp_user_lib.c
    ../src/bsp/inc/: bsp_led.h bsp_timer.h bsp_limit_switch.h bsp_level_sensor_input.h bsp_uart_fifo.h bsp_user_lib.h
